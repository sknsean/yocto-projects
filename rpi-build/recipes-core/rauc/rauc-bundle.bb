inherit bundle

RAUC_BUNDLE_SLOTS = "rootfs"
RAUC_SLOT_rootfs = "rpi-basic-image"

RAUC_KEY_FILE = "${TOPDIR}/files/development-1.key.pem"
RAUC_CERT_FILE = "${TOPDIR}/files/development-1.cert.pem"
